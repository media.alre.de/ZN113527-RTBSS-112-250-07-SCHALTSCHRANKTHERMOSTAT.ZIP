Properties of the parts of a building model (IFC2X3)

# File
Description: Schaltschrankthermostat, 0…60 °C, Wechsler, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: ZN113527, Schaltschrankthermostat, 0…60 °C, Wechsler
In: Raum
Description: Schaltschranktemperaturregler speziell zur Überwachung und Regelung der Temperatur in Schaltschränken, Getränke- oder Geldautomaten. Prüfzeichen UL und VDE. Das Gerät benötigt keine Versorgungsspannung.; Classification: EC004587 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: ZN113527; ModelLabel: RTBSS-112.250/07; GlobalTradeItemNumber: 4050528065216; ProductURL: https://alre.de/produkt_ZN113527
Pset_Specification - NominalLength: 0.064 m; NominalWidth: 0.046 m; NominalDepth: 0.037 m; NetWeight: 0.072
Pset_ALRE_ETIM_Properties - Montageart: Klemmbefestigung; Ausführung: Thermostat; Ausführung der Schaltfunktion: Wechsler (NO/NC); Bemessungsspannung AC 50 Hz: 230; Bemessungsspannung DC: 48; Bemessungsstrom In: 10; Einstellbereich Temperatur: 0; ETIM-Klasse: EC004587; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-ZN113527.pdf
